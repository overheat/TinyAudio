# IAR project TinyAudio.ewp, settings and files
configuration TinyAudio (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xE; USE_STM32F4XX_NUCLEO; HAL_PCD_MODULE_ENABLED
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\Drivers\BSP\Components\sta350bw; ..\Drivers\BSP\STM32F4xx-Nucleo; ..\Drivers\BSP\X-NUCLEO-CCA01M1; ..\Middlewares\ST\STM32_Audio\Addons\BiquadCalculator; ..\Middlewares\ST\STM32_Audio\Addons\PDM; ..\Drivers\BSP\X-NUCLEO-CCA02M1
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: TinyAudio.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f401xe.s
  group Application/User
    ../Src/: audio_application.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/sta350bw/: STA350BW_Driver.c
  group Drivers/BSP/STM32F4xx-Nucleo
    ../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-CCA01M1
    ../Drivers/BSP/X-NUCLEO-CCA01M1/: x_nucleo_cca01m1.c x_nucleo_cca01m1_audio_f4.c
  group Drivers/BSP/X-NUCLEO-CCA02M1
    ../Drivers/BSP/X-NUCLEO-CCA02M1/: x_nucleo_cca02m1_audio_f4.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_usb.c
  group Middlewares/ST/STM32_Audio/Biquad Calculator
    ../Middlewares/ST/STM32_Audio/Addons/BiquadCalculator/: BiquadCalculator.c BiquadPresets.c
